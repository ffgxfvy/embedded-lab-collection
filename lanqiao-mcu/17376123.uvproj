# Keil uVision project 17376123.uvproj, settings and files
target 17376123 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 17376123 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group Driver
    ../Driver/: init.c led.c timer.c key.c seg.c ds1302.c ds18b20.c relay.c
  group User
    ./: main.c
